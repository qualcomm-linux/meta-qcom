PACKAGECONFIG:append:qcom = " fastcv"
