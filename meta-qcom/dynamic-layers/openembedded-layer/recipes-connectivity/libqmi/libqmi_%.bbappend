PACKAGECONFIG:append:qcom = " qrtr"
