require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "826599d4ef60337f38de935f3049134489e3f703b874dd592996b013f8e9e40a"
