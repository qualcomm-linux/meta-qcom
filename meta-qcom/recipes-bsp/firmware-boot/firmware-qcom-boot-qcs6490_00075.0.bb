require recipes-bsp/firmware-boot/firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "38e6f424e02a8f99b9edf953e9d62b02489cb936426c58c48daf399ec6d5b60c"
