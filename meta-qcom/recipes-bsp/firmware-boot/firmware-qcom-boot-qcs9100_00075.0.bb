require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "c8042ef4668761f75021886b931d678339ca9cbab936a20f951a6ba747a77303"
