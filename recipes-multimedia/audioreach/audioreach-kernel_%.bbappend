FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-PATCH-audioreach-reduce-APM-cmd-timeout-from-2s-to-2.patch"

