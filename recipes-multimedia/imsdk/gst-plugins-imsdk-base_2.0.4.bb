require gst-plugins-imsdk-common.inc
require gst-plugins-imsdk-packaging.inc

SUMMARY = "Qualcomm IMSDK GStreamer Base Libraries"
DESCRIPTION = "Common base libraries for IMSDK GStreamer plugins."

PACKAGECONFIG = "base"
