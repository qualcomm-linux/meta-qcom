MACHINE_OPTEE_OS_TADEVKIT_REQUIRE ?= ""
MACHINE_OPTEE_OS_TADEVKIT_REQUIRE:qcm6490 = "optee-os-qcm6490.inc"

require ${MACHINE_OPTEE_OS_TADEVKIT_REQUIRE}
