# Enable KMS RDP Screenshare
PACKAGECONFIG:append= "kms rdp screenshare "
