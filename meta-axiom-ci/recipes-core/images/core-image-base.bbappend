QCOMINHERITS = "core-image"
QCOMINHERITS:qcom-axiom-ci = "axiom-image"

inherit ${QCOMINHERITS}
