#
# Copyright (c) Qualcomm Technologies, Inc. and/or its subsidiaries.
#
# SPDX-License-Identifier: MIT
#

# Root directory for Hexagon DSP libraries and FastRPC configuration
HEXAGON_DSP_DIR ??= "${datadir}/qcom"
