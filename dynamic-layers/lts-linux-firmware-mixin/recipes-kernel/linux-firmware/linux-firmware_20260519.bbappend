DEFAULT_PREFERENCE:qcom = "1"
