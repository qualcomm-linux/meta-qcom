PACKAGECONFIG:append = " sample-apps"
