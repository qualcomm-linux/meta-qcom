PACKAGECONFIG:append = " camera camera-apps"
