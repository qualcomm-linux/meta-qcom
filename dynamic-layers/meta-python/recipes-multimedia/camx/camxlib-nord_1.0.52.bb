PLATFORM = "nord"
PBT_BUILD_DATE = "261012"

require common.inc

SRC_URI[camxlib.sha256sum] = "630def9c94c1a6224e96ff7de97bd82d44c81f0f5a51abed1c446c4f06b08ed7"
SRC_URI[camx.sha256sum] = "0a1145eaf43bc29a309ab24a55b7ecaac7090f5d6cf6ee98dd0910f4f75a52e1"
SRC_URI[chicdk.sha256sum] = "44cc22f3ef617d3e586739b3cb9415d59577e439b4972925503b28add07d64d5"
SRC_URI[camxcommon.sha256sum] = "7ce235d0641c015003a3f5c375291f9a0acef7d59ab58ba3534d6f4abe7e7c64"
SRC_URI[camxtest.sha256sum] = "826dc2907b7ddf94dcb8714cc2be8aa32b1a3f38df8dd69f34e822d1f77f1420"
