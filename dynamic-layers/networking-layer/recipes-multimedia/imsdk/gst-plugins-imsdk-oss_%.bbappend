# mosquitto, needed by the messaging plugins, is provided by meta-networking.
PACKAGECONFIG:append = " messaging"
