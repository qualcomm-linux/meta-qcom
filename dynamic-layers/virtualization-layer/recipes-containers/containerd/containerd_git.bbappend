do_compile:append:qcom() {
    chmod -R u+wx ${S}
}
