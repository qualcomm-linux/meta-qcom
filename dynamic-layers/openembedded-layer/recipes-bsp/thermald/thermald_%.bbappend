FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:qcom = " file://0001-thd_gddv-fix-building-on-32-bit-systems.patch"
