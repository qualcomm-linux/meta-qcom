SYSTEMD_AUTO_ENABLE:${PN}:qcom = "disable"
