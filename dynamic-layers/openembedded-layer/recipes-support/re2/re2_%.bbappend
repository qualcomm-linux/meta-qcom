# Temporarily revert to old abseil-cpp version
DEPENDS:remove:qcom = "abseil-cpp"
DEPENDS:append:qcom = " abseil-cpp-camx"
