PLATFORM = "talos"
PBT_BUILD_DATE = "260307"

require common.inc

SRC_URI[camxlib.sha256sum]     = "8d0d704705182b9ac0b76a882471d1b74d472080e3de0e048ef73a2ff3622332"
SRC_URI[camx.sha256sum]        = "3dc40b3f1541f4a5bf6cbfc22bd17379137eb136c850ae1008c9f8003820bfdb"
SRC_URI[chicdk.sha256sum]      = "da939b1a04ecd2c2ca531165aae8f329035b52b9b8331f8212caad19e4ba29be"
SRC_URI[camxcommon.sha256sum]  = "52529598144b13c303261c76592a9ae8b617e54cc7ea1516f555de9598948f4a"
