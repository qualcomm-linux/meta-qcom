PLATFORM = "talos"
PBT_BUILD_DATE = "260209.1"

require common.inc

SRC_URI[camxlib.sha256sum]     = "9ad1a02dc0c5aba8bd8a10131b7b4a6dcd907200a2cfd4dbb92f5b37bed9eed8"
SRC_URI[camx.sha256sum]        = "2cc31bcbd31834869a0c3dd9b3f5bfc7b803ce0fc7a86502fbf07dd3de1853a3"
SRC_URI[chicdk.sha256sum]      = "0e013f41915ef799b59e0756879584fb450e1bab9078ed1df3c440b18de4af62"
SRC_URI[camxcommon.sha256sum]  = "d3bc8e560ceec070aa8bf100e2296342c26c4a8aea9def4d186370e5449f0c92"
