PLATFORM = "talos"
PBT_BUILD_DATE = "260512.2"

require common.inc

SRC_URI[camxlib.sha256sum] = "becf80216e5655eb0b3927ca9597df8ac0afc38abf55fe7bd166c1cf9a65e503"
SRC_URI[camx.sha256sum] = "162e480fb2128fa0e8d775f8f84b355147402f2604f058da68f80d3052a60cd9"
SRC_URI[chicdk.sha256sum] = "9ac9f0131c0ba9d6b9994ea28be1f8966eda91f08986876a296f902df455b28a"
SRC_URI[camxcommon.sha256sum] = "3e0fd7c97e921bea885c73e8ff17992bd2fbe55297b2d523488fd7a6a9c37078"
