PLATFORM = "talos"
PBT_BUILD_DATE = "260302.1"

require common.inc

SRC_URI[camxlib.sha256sum]     = "f2dfc95b3497744a4673688dd7939ca7bb02153f6d4497d05ea7ce26f37f440e"
SRC_URI[camx.sha256sum]        = "7444b265bd12983d0816cf906696fdaeb27e6c7d81a0a6c2f882f29c2dfbea96"
SRC_URI[chicdk.sha256sum]      = "e0c83364aedd43c2b6d4849b2a2df8d80c7fa11ba59cfd3115fde583822c98d7"
SRC_URI[camxcommon.sha256sum]  = "8450f1524574f99def6d703550fa2466398ebf7ab1c4f3a3505d5391069bb4bf"
