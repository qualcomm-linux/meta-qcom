PLATFORM = "hamoa"
PBT_BUILD_DATE = "260520"

require common.inc

SRC_URI[camxlib.sha256sum] = "cd321d37bbfe4fdbf8e2fce649185b703bdda9e5252af9e7994617cb5f6f156f"
SRC_URI[camx.sha256sum] = "2c43d0ad848cb18ee3579e9b908d2408cf14e0f27dc41a976b65007a83d4f567"
SRC_URI[chicdk.sha256sum] = "933f8a4a8abdd66faa3772fb493900fd1ff82c08346dac2d455f3335bae4b8c2"
SRC_URI[camxcommon.sha256sum] = "b36265c5a33f1a83e0659a89eb58e1cc3abc9bc02619d000a8c9cf112a451f62"
