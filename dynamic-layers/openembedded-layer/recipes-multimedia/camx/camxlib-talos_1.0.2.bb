PLATFORM = "talos"
PBT_BUILD_DATE = "260211"

require common.inc

SRC_URI[camxlib.sha256sum]     = "772f3f7970db9d639a87d55fd9bac07cb9726866d5eef7b983dcfdd86ec14415"
SRC_URI[camx.sha256sum]        = "b860fde72e6a965cc1811afedb164fdb593338325fc80476026d11f9800ebfe9"
SRC_URI[chicdk.sha256sum]      = "dd38a3d1599cfe5ef2fa40b5eb00016b03fd9800c919edd7689857193a5d1d7e"
SRC_URI[camxcommon.sha256sum]  = "3cdc8717e8778d4f19231067a82e44dddc563f8e05bf058901f0b74784312fa7"
