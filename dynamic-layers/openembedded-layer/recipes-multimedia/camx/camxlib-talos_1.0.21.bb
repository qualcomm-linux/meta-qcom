PLATFORM = "talos"
PBT_BUILD_DATE = "260428.2"

require common.inc

SRC_URI[camxlib.sha256sum]     = "401e9e2443a2704b9e8e9d9a0fbac823c3df39b70757f6d3abc278fe36ad246b"
SRC_URI[camx.sha256sum]        = "199cc07a6349d820cac766a7fc26cd977cc003c6a68b51bf79a7c8a836d08e91"
SRC_URI[chicdk.sha256sum]      = "97f0f28506883510cb69d7c7390dc64507c4647c55f7cd52ca1fec46958d725d"
SRC_URI[camxcommon.sha256sum]  = "cbd294a2cad1ac576061f13f0805ce58476943d2ac6066ae464ecd42f004b7a9"
