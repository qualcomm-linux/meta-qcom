PACKAGECONFIG:append = " camera-base qmmfsrc sample-apps-overlay"
