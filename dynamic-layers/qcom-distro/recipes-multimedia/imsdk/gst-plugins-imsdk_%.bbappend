# Dependency recipe for tflite, tensorflow-lite, is provided by the meta-qcom-distro layer.
PACKAGECONFIG:append = " tflite"
