# Dependency recipe for tensorflow-lite and litert is provided by the meta-ai layer.
PACKAGECONFIG:append = " tflite litert"
