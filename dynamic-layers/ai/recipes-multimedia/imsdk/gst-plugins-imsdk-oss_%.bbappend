PACKAGECONFIG:append:qcom = " onnx"
