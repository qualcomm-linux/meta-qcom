require optee-os-qcom.inc

OPTEEMACHINE = "qcom-shikra"

COMPATIBLE_MACHINE = "^$"
COMPATIBLE_MACHINE:aarch64 = "(qcom)"

OPTEE_DEPLOY = "optee-shikra"
