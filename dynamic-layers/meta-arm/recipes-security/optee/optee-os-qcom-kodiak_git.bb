require optee-os-qcom.inc

OPTEEMACHINE = "qcom-kodiak"

COMPATIBLE_MACHINE = "^$"
COMPATIBLE_MACHINE:aarch64 = "(qcom)"
