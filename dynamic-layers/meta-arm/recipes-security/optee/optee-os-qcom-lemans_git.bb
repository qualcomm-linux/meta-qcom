require optee-os-qcom.inc

OPTEEMACHINE = "qcom-lemans"

COMPATIBLE_MACHINE = "qcm6490|qcs9100"
