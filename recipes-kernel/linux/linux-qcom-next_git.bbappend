FILESEXTRAPATHS:prepend := "${THISDIR}/linux-qcom-next:"
SRC_URI:append:ipq9574-rdp433 = "file://configs/ipq9574-rdp433.cfg"
