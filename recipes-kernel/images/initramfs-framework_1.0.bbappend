FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-initramfs-framework-limit-udev-trigger-to-block-devi.patch"
