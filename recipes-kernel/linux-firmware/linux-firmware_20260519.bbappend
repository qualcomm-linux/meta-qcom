DEFAULT_PREFERENCE:qcom = "1"
DEFAULT_PREFERENCE:class-devupstream:qcom = "-1"
