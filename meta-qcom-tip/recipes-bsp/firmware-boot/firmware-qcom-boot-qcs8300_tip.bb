require recipes-bsp/firmware-boot/firmware-qcom-boot-qcs8300.inc
require firmware-qcom-boot-tip.inc

QCOM_FW_SOC = "qcs8300"
