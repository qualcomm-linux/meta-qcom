require recipes-bsp/firmware-boot/firmware-qcom-boot-qcs9100.inc
require firmware-qcom-boot-tip.inc

QCOM_FW_SOC = "qcs9100"
SRC_URI[qcs9100-ride-sx.sha256sum] = "377a8405899ac82199deaf70bca3648c15b924a3fcef8f109555e661ed70f4b9"
