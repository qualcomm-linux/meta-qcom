require recipes-bsp/firmware-boot/firmware-qcom-boot-qcs6490.inc
require firmware-qcom-boot-tip.inc

QCOM_FW_SOC = "qcm6490"
SRC_URI[rb3gen2-core-kit.sha256sum] = "0fe1c0b4050cf54203203812b2c1f0d9698823d8defc8b6516414a4e5e0c557e"
