QCOM_FW_BOARD = "QCS8300"
QCOM_FW_SOC = "qcs8300"
QCOM_FW_NAME = "QCS8300_fw"

FW_QCOM_NAME = "qcs8300"

DSP_PKG_NAME = "qcom-qcs8300-ride"
DSP_QCOM_VENDOR = "Qualcomm"
DSP_QCOM_DEVICE = "QCS8300-RIDE"

require firmware-qcom-tip.inc
