# Tensorflow-lite needs an extremely specific version, so lock it to that

PV = "24.3.25"
SRCREV = "595bf0007ab1929570c7671f091313c8fc20644e"
