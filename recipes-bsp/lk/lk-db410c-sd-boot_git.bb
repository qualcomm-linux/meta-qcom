require lk.inc

LK_BRANCH = "release/LA.BR.1.2.7-03810-8x16.0+sdboot"
LK_REVISION = "089944963d354403ab3b6a37b504c29f0949ecdc"
LK_MACHINE = "dragonboard-410c"
LK_FLAVOUR = "-sd-boot"
