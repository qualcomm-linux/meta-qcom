require lk.inc

LK_BRANCH = "release/LA.BR.1.2.7-03810-8x16.0"
LK_REVISION = "0a10f81d847e005244cfa59d7f4dd8c6acfd82f6"
LK_MACHINE = "dragonboard-410c"
LK_FLAVOUR = ""
