require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "e07ed2b58c639373e22c289873f1059a4ba48cfe41bd9ae2f9651884177b60c9"
