require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "efe9e256054eb07dd347059afb9f2989c47ec1214c2050012d9502e6a783e57f"
