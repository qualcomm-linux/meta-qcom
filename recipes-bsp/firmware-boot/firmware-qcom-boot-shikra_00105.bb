require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "7909ce61c789a5dae1e3e45e04ed6e6186fa8a000b07535ca5ce17c2828eaebd"
