require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "df2437405516034fb2d33585c8436891f7fb765e92022256364b4cf609089d0e"
