require contentsxml-qcom-boot-qcs6490.inc

SRC_URI[cxml-qcm6490.sha256sum] = "42b384c0a82ffc294ffd690294b0261aadb2aa7bb6d85dd3eea522b50f90e7a3"
SRC_URI[cxml-license-qcm6490.sha256sum] = "3ad8f1fd82f2918c858cec2d0887b7df6f71a06416beecfdb3efe7d62874d863"
