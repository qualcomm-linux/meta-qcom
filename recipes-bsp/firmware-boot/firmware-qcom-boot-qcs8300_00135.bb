require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "67b023c4b18188ac5f4c0f50b656902501cf8c735982b7b099493bea85da4a21"
