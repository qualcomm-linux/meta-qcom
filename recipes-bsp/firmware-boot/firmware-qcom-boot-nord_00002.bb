require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "b1d065a274fc39bfa62cf32438311b7694d7283c08b2150784741e63d2923794"
SRC_URI[bootbinaries-immutable.sha256sum] = "e151532073147aeeae540745d2d0e1f311a37647c099d3488099d9a9508e1441"
