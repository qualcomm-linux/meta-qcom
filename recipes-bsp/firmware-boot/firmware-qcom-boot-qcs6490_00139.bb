require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "f96e46fe2d6696649e0bb7f2feb93c234a0fb73328d26f24bcf991e6d3f447cc"
SRC_URI[bootbinaries-immutable.sha256sum] = "32c4c19fa0f446ed2b64cef9daee6cbaef56232226a596172f4eb723b313ccbb"
