require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "9dd27d1750347b499c71fe93c3fd25e8f5359d6ce064dda604bf6f270169f391"
