require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "feb12f464734c0a46200aa924220cc79c9890bb4efe969a8c5a7831565bdf1fb"
