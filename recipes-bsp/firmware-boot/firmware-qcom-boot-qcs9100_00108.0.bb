require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "6f1e31e51521f644791638c80ac9feb19b7170eb8e65f8f0c28559cc8a6bc264"
