require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "46caa2c4a6b78f32335d606181d541c943cd2efe3b768e7a7a9683e82b1a8a0f"
