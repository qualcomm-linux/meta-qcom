require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "ece94c92b42ccc82e306df2c5f966ce0e6e5761cb3efefdda78c632da4d4a822"
