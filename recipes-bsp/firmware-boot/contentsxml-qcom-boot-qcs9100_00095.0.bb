require contentsxml-qcom-boot-qcs9100.inc

SRC_URI[cxml-qcs9100.sha256sum] = "357cce722dad4551c7ae229dde8eae5c7218f0c8d97380e46bf3a35236b0aa9b"
SRC_URI[cxml-license-qcs9100.sha256sum] = "3ad8f1fd82f2918c858cec2d0887b7df6f71a06416beecfdb3efe7d62874d863"
