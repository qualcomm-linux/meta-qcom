require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "273bf23ada52eb420850fa32b727c81622491d67c77b8b9b7bfcfe09078f85e3"
SRC_URI[bootbinaries-immutable.sha256sum] = "22683804350a3def503c663c63b36a8b07d05d7918fbbc91ef16af60f53b8430"
