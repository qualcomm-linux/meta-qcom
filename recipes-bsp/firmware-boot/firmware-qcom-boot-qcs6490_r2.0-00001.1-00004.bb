require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "48d50c22d1b1e09ea2af1ada2adddee82bcf16a494fce656e8e3f5a694cef830"
