require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "ee2add1566e43ba642274240c4c9f76cdb5743110a0e4990687485a3fdd38b6f"
