require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "1ccb06dc7ff54f788b7c7971e89a6424cffcec7adb2e7af24e530d665dbd5ca4"
