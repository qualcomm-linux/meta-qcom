require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "82abec551e305643ec0acfd9bff77b6fc27c410220ef0ce4b0bce30d268387de"
