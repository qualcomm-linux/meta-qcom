require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "b26be9d7254fecae3732f20f98e519f3efc154efcb7e2e12888b321cfeb25a33"
