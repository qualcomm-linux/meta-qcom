require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "6fe0ab9009d4b549daa308ac1c4220e8bb05ab9f0166f954e0c26c30932e7dc2"
