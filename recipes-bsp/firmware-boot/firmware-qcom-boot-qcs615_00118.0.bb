require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "6730c26235880f469075acb62115c9e1e566979d1bf12f4a4c4ecf590c1d357e"
