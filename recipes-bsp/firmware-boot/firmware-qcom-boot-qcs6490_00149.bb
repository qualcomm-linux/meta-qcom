require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "01a83c4559cbcfb1b342b49d53ff3cfbcd4a6b27772752c75a2a1f4cb1b4214f"
SRC_URI[bootbinaries-immutable.sha256sum] = "105fedd738e7aa63b0a833f5ac217e62730311554a7a1ba7797fe2d490382e91"
