require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "d1f71348523bdf8c8eeebfa464f39cdb3a27772d2f41f70ddfb69e4f700fb4e7"
SRC_URI[bootbinaries-immutable.sha256sum] = "950978f97debf8a8d7386604235c0161ba2a80ca030095d4ef512ea165383f33"
