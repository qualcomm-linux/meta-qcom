require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "aab9817b918dc804bd47b343293fa386d2aab15fc9df620b0fe56f8f474ef97f"
