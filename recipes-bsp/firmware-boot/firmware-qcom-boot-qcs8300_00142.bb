require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "22182317cfe5b09f8cc9bc428d755391561cb9d25c9e77aeca4e62195d4b97e8"
SRC_URI[bootbinaries-immutable.sha256sum] = "ffc05bf1323d828f8c944421d8cadaf1c45697032b26b9f34ecce042ddae291d"
