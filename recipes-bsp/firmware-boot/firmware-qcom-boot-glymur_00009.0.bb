require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "79df8ab4cc3248472d819098d20829ab129828c19937525cfc16f089d65a7a42"
