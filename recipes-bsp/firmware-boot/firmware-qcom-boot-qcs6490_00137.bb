require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "24315170167192c63e4969d85d4b20b2bd9311f6b2a72220af571d2ebaa51e2a"
