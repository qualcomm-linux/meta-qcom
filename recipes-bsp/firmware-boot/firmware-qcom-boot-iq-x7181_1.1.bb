require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "8a2ab2f320995a4e89511218a1e81f8811f264f5881ebcedc601b26706858fb5"
