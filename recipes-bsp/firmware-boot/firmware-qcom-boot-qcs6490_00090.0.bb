require recipes-bsp/firmware-boot/firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "04d4a061a524604643b06abfa7c177789b0fbed225b706e4fcecd3d3a03130fa"
