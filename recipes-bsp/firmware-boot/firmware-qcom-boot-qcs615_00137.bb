require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "a7db0177218ce14cf52d514d3f9413f905b83004a4318b279cbbf73242676fd3"
