require firmware-qcom-boot-kaanapali.inc

SRC_URI[bootbinaries.sha256sum] = "2780de144c1f0bc859e040005ef18d19947d8b7d2bfaaa8cbb76effb7a7f091c"
