require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "5fd973d2cde266ef40fe1352cd360dced55e1c2dcc0e82f51d249c512875d528"
SRC_URI[bootbinaries-immutable.sha256sum] = "2a8a4b6490dcf66b730c418ba0f5a0333bdf2d593aed3673c66f71c0bb16b3eb"
