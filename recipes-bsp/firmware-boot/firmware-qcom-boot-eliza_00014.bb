require firmware-qcom-boot-eliza.inc

SRC_URI[bootbinaries.sha256sum] = "0bfe4c7eb19b0ea0cf1651332f6a0ad75bb0e787f112999c85cbf86cc0c0d885"
