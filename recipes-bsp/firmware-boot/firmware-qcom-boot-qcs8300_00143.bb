require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "518f502ed51d849adfa37646e013d269aa73441f8c83485292437fe18b47ab00"
SRC_URI[bootbinaries-immutable.sha256sum] = "3b925227c12db19c5bf5f13ce844fb8e036cb7ce05a213455a512b5f1ea5c882"
