require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "e5ee0e7788294470df2bfb690b97cf5953340473776a44b8c1a4cfa2b7aceaa3"
