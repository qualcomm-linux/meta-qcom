require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "22e45047b3349a1611d27167616dd04f08e8351120ac121f6921b47b9f709216"
SRC_URI[bootbinaries-immutable.sha256sum] = "a5f48c1646eb640377b66fa13064f2efe6f667e60f714b0e06c34dc66b7c94fb"
