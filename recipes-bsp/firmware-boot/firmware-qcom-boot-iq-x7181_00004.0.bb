require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "6dd565b0e481e32c416db05277143d52c4088683feb70c3a0c365f594bda9552"
