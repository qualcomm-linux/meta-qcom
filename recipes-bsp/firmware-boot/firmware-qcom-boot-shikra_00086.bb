require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "5069ba57cfacae02c26922f069d32d79bc6e41b3ed65496f8edd6b1fcb7b71fa"
