require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "b3152d0ca2d07c01bcfd78e6244825924d5ae8d05fdc0f5684294fdf9e52667d"
