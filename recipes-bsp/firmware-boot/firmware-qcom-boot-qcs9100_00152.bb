require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "fb3e570c73d0296ddf9a51cef7aed7345d389628e01d00f6f91eab70746e45ca"
SRC_URI[bootbinaries-immutable.sha256sum] = "f7725097185d8887417a71f8d3038e0d2fb13481a0bd0864a97fff4f556d25e4"
