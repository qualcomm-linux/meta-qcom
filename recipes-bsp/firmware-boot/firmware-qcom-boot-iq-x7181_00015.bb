require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "6b12777ac79ec40665bc9aa5772d6f63a85306d4ecbdc66bcbb9ae2ec3797374"
