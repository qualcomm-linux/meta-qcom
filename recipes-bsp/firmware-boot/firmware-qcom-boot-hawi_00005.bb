require firmware-qcom-boot-hawi.inc

SRC_URI[bootbinaries.sha256sum] = "d065e2a6d341d0f5f9261229b07d91e62f58a7a0c6bcaddcb2257b68f14b89ce"
