require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "b1d06ec859b37b903988cb9b419fd499a0ad3739e951362c88f25b9c1913a567"
SRC_URI[bootbinaries-immutable.sha256sum] = "523c07b1059f2543cae7969e33652f9dcb2cfe1d8862baae32488f49d215e60f"
