require firmware-qcom-boot-sm8750.inc

SRC_URI[bootbinaries.sha256sum] = "d434298327f46d25f97b8893b0604fab898886c56cb0dd263cb88d8b3fdad8d5"
