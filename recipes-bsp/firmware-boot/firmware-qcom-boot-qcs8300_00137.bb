require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "54c2b7634807a78dc77f3371004a63ab510b46ae1fc92dbfdc72de1b6d18459e"
