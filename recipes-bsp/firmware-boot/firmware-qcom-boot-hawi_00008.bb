require firmware-qcom-boot-hawi.inc

SRC_URI[bootbinaries.sha256sum] = "da76297deb431c133cfa9fab5ca6001db06c3cb96f73cab8103af02aacda9503"
