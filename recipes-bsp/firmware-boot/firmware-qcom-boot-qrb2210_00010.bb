require firmware-qcom-boot-qrb2210.inc

SRC_URI[bootbinaries.sha256sum] = "70168afbb254b901d17111bcfcd627af2bfab326cf5e0a007feafafa6bc63b72"
