require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "4704b117672ef778c4680522b753af00641e91fc2f7fb351d942559e09458352"
