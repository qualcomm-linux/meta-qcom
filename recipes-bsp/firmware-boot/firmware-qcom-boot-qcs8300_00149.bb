require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "1af78a7d005649c245b1ed4bf507fccbc91f25bbaabba807816760276e8c5e29"
SRC_URI[bootbinaries-immutable.sha256sum] = "36b58328016415e197cd98607d7224155405fb35f6c48c7cdfa3d6dfbe34afda"
