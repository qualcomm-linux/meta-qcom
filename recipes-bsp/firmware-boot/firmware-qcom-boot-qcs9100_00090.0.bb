require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "34b8d8c8cb107145f96837e4b7727fb3ddc157708622bd4797290169ed5c1510"
