require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "2477f98d66023a4cd59e7b8cca53dae1c8d2383979534e66348183f40b29d775"
