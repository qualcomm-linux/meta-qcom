require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "621d2b4e78177742ad3377854d5ef5de7d38694495016b914e38bf431e44a1f4"
SRC_URI[bootbinaries-immutable.sha256sum] = "cdf2d0b81bb6324209860db2de2686f850cc3e5ff3d44d2ea270adb8a92426f8"
