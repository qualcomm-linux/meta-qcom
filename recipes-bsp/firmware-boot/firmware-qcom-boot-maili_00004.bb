require firmware-qcom-boot-maili.inc

SRC_URI[bootbinaries.sha256sum] = "75cf0c4e75c61ab6247620ffc8591ad9d48e1a8ebd9a56c49d94ca92ec3307a0"
