require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "27a75ae6588ce23fce5498378a433db933fb667b1dbceb0dae4844c7d90eaef6"
SRC_URI[bootbinaries-immutable.sha256sum] = "d232085dd6f92cd9795718aaba98722a8f79dca3ef187b437bd88f40a6cf5da6"
