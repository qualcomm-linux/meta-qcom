require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "9239eb9a78096bbd0d484a51a4c0ae8914fd9d41c93c57f121725529a6ce2b5c"
