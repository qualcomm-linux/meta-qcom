require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "8dcdbbedaf3ec0fc26cf438222e06d141c8c9a17ba87bbf7f888341145d9c8ef"
