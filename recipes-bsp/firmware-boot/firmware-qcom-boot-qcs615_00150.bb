require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "0bdafedc2b04c7a91ec977a05dca035832f70597712e69f9d4d392c0001b1b18"
