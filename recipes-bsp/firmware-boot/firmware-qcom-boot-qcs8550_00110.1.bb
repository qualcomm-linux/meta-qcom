require firmware-qcom-boot-qcs8550.inc

SRC_URI[bootbinaries.sha256sum] = "2e56d7f130d71a50d97967e96fe4802533c13882b30c0a7188514c7d24fa93ec"
