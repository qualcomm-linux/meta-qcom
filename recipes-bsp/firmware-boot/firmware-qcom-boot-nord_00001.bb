require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "3de641b121db3048e3c0823356cb34b6e192c6cf510e7d20d4315dbf6b77b7ac"
