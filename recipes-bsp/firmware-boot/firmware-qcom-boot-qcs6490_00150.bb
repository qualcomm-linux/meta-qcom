require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "f6982fed9eaa546649f53c4aedc960f031123c3b7dac06803dc7dabbff533ee0"
SRC_URI[bootbinaries-immutable.sha256sum] = "711986b7e8ef86443bdd967c3ca4132b7d3db5ad9b5cfbce71bd09d0079fb7e9"
