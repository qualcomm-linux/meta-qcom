require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "23975e805f30cceb63b82b8df3b377aea28f11c6b8f3765a0eae98c89be6c8c8"
