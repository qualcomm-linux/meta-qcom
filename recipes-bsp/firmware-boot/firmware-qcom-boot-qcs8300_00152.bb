require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "2d52bcadb9f466875e392968059d62470d271e8f7a7437bb4d10f154132c0210"
SRC_URI[bootbinaries-immutable.sha256sum] = "fbf69dadbb0b7653874bd10f636811bd83a6661195de0fc69620039c1f43b9c9"
