require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "e247c26a8b2703afda95708d4812ce9114f808cc175c06440076373487881c3a"
SRC_URI[bootbinaries-immutable.sha256sum] = "dc4fab1852bf53b2d071eeca9b1e1e60dfefe906e392a335dca9ea69de93b97c"
