require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "536415482ad869f65b727b5244dc82e3579d24e62cd9273ebbbed904159c3665"
