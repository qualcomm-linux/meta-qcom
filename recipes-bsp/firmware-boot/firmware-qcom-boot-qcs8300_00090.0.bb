require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "f0c343c29a4d36f60adc8c0a229b45660a97dbcda88002e311e8b7b5e080b93c"
