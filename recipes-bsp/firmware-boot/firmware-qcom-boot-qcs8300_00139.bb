require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "14adec4227442fb5ede2c235dea80fd2fa6b65617d8582d1392ef0e6cb0973e9"
SRC_URI[bootbinaries-immutable.sha256sum] = "b6bd6d706d82ed359df07ea97d0f82d742f45b9153580dc1db54d25207b95d91"
