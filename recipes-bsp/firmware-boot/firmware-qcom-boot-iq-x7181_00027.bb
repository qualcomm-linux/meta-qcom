require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "8d654b956a537182d035e1e6bb3c41c2d2b78c6672d0e5936d2668b938ef1c67"
SRC_URI[bootbinaries-immutable.sha256sum] = "4d170f40d09c52c109420edccaafba9aa7b1243e9b2c57d090f6c239a805b5c5"
