require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "78f13c5093028389c4040ae453e592ceeaa80f1891135a04058bbbd0abb5f563"
