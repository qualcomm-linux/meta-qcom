require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "9cc8be5edede2f534e84c2340d3b7fe07af2369124f61610b3eda1ed90ddb737"
