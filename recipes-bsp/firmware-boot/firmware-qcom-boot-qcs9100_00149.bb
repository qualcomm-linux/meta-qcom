require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "8fd89810fa9c7c854b0e2eedf929d2a85b41d7e2e234b95c1bf304394975e82a"
SRC_URI[bootbinaries-immutable.sha256sum] = "61b545dd38d47bd69aa6d9fc4773809fe4836bbd722654a83b4be0d558174132"
