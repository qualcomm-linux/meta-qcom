require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "fb0f29a9d092ed127e6ea6eb6ef44332bfeb8fc487fc305b6a48fd65e053b78e"
