require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "b95cad4192c7e0fbb39ab4144b170cacf8ff5fff2188c08b36b440316e48d039"
SRC_URI[bootbinaries-immutable.sha256sum] = "b42859ee61012bb93464caa2751ee19db82de9eb571ee351f8bbe7e967a85a7b"
