require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "1277191d5ec4fb959e8845392316117cccfbbe20d7ac2ea7c33a6c0210e9b662"
