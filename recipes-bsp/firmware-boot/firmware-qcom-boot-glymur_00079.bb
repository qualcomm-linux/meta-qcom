require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "b8063fd1dff26bdc289d96ceb21edb6fcc0dbd604277a948df43699299b32649"
