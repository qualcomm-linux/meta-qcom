require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "43549a7dce32134f81706fd2d0e3550a655563ccdd708d11b89480281485003e"
