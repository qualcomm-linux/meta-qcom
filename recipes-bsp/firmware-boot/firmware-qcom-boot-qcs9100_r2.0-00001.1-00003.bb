require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "c8d09ea92523378b2ad16f05eadd28bdb37eb25d210abff24bdf58332316752e"
