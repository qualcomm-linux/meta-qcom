require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "55281beda462f61cb4ea1d075510e275dc2a51258d3e4e903267a1c711c107ee"
