require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "d7630c1fbe7857ce36897b6bf3be9031f8466e77bc10687dd9625d4a9a0c3132"
SRC_URI[bootbinaries-immutable.sha256sum] = "eaea1faea542fcbe5e6bb4e4ffea39fa4595e942351a5bef36e6700d9d89ff36"
