require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "ab9e2349c18ac761522c31822a6874818ac027f9560e36cb83c48103ff96a2c4"
