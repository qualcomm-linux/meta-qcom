require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "4e771681491dc6f5a8c7fcef4c05d2a4fc8c29ce016fbfa887d9355173189ed5"
