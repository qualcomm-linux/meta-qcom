require firmware-qcom-boot-kaanapali.inc

SRC_URI[bootbinaries.sha256sum] = "3efc9cbe88726a20f2bfedd7f59b508546f0ba66fddd397b50007ddbeef4af92"
