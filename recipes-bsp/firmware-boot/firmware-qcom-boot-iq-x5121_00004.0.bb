require firmware-qcom-boot-iq-x5121.inc

SRC_URI[bootbinaries.sha256sum] = "fe987d99a6a0ad5882c05a416ae38694fbe1f9411489b1ad2d505ac4e59ddfe9"
