require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "f847ad4802bfb5801e0cd5554538f4793c6a144ec76b9a2a3cfae04cc74979dc"
