require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "1e1a146b0b892a143b34484e4e0f7d80d5138b3664501adc4541bece8e27f90f"
SRC_URI[bootbinaries-immutable.sha256sum] = "30e3561de660c554c48f9eb9193e1de3481714706e27ee087a3eaed8a5798c89"
