require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "17d2c5bae5c17b665bafd9bba8962f41aec7be2f874cde90b0976730f0098bf6"
SRC_URI[bootbinaries-immutable.sha256sum] = "1aa0b67671ef026a40ca133f32128d07fffd614a47cf51eaa5cd5c7d4941d034"
