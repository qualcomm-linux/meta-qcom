require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "9928e12bf7d6eacc9e7059915f254e5e6276d6f84c136bc689fc6d6f7b1b019a"
