require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "590731ed48217542f97030eec870db544d051e370bc57e5f775eb5598fcc8292"
