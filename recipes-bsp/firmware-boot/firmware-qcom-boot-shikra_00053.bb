require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "f3f9508288c7d9b10119dae3e423fee3edfc74f720394b0204e3cbafa0fc9542"
