require firmware-qcom-boot-sm8750.inc

SRC_URI[bootbinaries.sha256sum] = "3e09eef0dbdecf2c5680f9278ed4fd6f32b0b5f89cb16e7ad3459a56986c4469"
