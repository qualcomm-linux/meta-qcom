require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "4116a6368262edaa58d7a4d79d94099dffa06e1af54d5c0f8f47fec93fc8dc85" 
SRC_URI[bootbinaries-immutable.sha256sum] = "c3311939169d2a83d0c9500007f16c782df8eec8295b3c7a71a9f0a373956ee0"
