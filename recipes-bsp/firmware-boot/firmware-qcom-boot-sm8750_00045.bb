require firmware-qcom-boot-sm8750.inc

SRC_URI[bootbinaries.sha256sum] = "376818f0c41e2356cbd2225ba467671ddb81a75e9c87ce040721a29b30b308cc"
