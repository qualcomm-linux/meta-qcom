require firmware-qcom-boot-glymur.inc

SRC_URI[bootbinaries.sha256sum] = "92a0955c63b989eaf2b518d5407ef23fdf67c3a80346c80ffc2277a04f07936c"
