require firmware-qcom-boot-nord.inc

SRC_URI[bootbinaries.sha256sum] = "198c666c1477661301cceab7481aeb8bd698309301dfd3fec4128cd32a1022c4"
SRC_URI[bootbinaries-immutable.sha256sum] = "1195a5f7b0e1443e29f0f2135b07c48493703cf38bd40ce6a41781a9fe57c326"
