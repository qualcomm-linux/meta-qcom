require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "6150c43a55ec95a9e11e288df1a1670a7dc75981485de93376969cb573c9a3c5"
