require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "021f55367fe8ee9444000236ab82b5127dd6d73b9c25573b30476bc7fb88bffb"
