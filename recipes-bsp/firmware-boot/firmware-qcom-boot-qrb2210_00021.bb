require firmware-qcom-boot-qrb2210.inc

SRC_URI[bootbinaries.sha256sum] = "26a8681834363cb8bc9e8149db27388406daf22af15d3b43c9649e180afb47f2"
