require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "df1b928a25f428f4c76a760be8a094104cec75cd5a6f758d9e3c62ad9be71c0c"
