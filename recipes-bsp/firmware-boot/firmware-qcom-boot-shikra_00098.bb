require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "255e837c9c8aeb726bcad3d9ce8454208f7b9b1e6b6265d4f7c87b2d9b363edf"
