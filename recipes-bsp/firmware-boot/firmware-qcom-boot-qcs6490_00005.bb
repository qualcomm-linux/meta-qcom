require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "42c8955f889945610324e2695d0b36618e1105b1cfaedc3f2f668eeaa73169ce"
