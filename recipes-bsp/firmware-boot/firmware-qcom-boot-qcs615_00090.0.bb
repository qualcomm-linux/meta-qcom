require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "13f7cb56b505e0177c242dadc8bf1b8cf92aed9ef6fa31604796b0e937910fcb"
