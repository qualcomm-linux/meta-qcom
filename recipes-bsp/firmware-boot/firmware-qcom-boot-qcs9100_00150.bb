require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "52af8fa3460c937fe1853e6cc8f3f9fa1235c4bc0eeb1a51b572305cc82c63e7"
SRC_URI[bootbinaries-immutable.sha256sum] = "2f905f457a9583a183fde2858a0880fb3acc141d38a82ced8ebfd5cfc6a8e3ae"
