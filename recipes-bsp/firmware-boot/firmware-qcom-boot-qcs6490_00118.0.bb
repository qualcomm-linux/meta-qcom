require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "754598969a7ef6b2df448fb64d4d6b762415e8a8ea3c2a202c9a0e98a930f432"
