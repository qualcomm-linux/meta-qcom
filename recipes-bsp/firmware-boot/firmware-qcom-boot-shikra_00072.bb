require firmware-qcom-boot-shikra.inc

SRC_URI[bootbinaries.sha256sum] = "a123a9e7e4d7627962a39e6eb0d3773a52d7c43481961eda2e4bb21663b4e7db"
