require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "f442bd476b64312969d49e5b5369744e19ab193f0f8c05986b96307b65161a80"
