require contentsxml-qcom-boot-qcs8300.inc

SRC_URI[cxml-qcs8300.sha256sum] = "75fe177a10592fd6d076a8d5373e42c2c2d807436f420f527a8bf6df2d137a7c"
SRC_URI[cxml-license-qcs8300.sha256sum] = "3ad8f1fd82f2918c858cec2d0887b7df6f71a06416beecfdb3efe7d62874d863"
