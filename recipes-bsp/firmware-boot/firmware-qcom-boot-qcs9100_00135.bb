require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "2db1108f41ea9feddff0303be7e0b0af4fa66ce7405ee6e874749a9f4f266e82"
