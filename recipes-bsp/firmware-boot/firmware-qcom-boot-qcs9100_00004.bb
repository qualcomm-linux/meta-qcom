require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "7d3dfdf24ffd4b5fbf536347119b711235a338fcccc06ddc94f6e620036f6f99"
