require firmware-qcom-boot-iq-x7181.inc

SRC_URI[bootbinaries.sha256sum] = "f43954b08d589168f96434ec123b8f940589b7895129d2a8965f6b0f97e99710"
SRC_URI[bootbinaries-immutable.sha256sum] = "34f35ec39db203ad5627af92f471259fccd1b1d593cb7d9e7a3aaf3412a5b94f"
