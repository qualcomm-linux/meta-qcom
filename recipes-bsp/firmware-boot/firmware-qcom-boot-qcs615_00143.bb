require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "669d2d9d39ffb306c737f97836b52bb584dfb329910e70ee000f72d3dd0bc302"
