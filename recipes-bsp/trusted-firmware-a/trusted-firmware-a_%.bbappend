MACHINE_TFA_REQUIRE ?= ""
MACHINE_TFA_REQUIRE:qcom = "trusted-firmware-a-qcom.inc"

require ${MACHINE_TFA_REQUIRE}
