FILESEXTRAPATHS:prepend:qcom := "${THISDIR}/${PN}:"
SRC_URI:append:qcom = " file://pr-282.patch "
