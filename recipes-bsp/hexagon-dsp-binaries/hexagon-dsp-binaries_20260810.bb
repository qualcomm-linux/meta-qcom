require hexagon-dsp-binaries.inc

LIC_FILES_CHKSUM = "\
    file://LICENSE.qcom;md5=56e86b6c508490dadc343f39468b5f5e \
    file://LICENSE.qcom-2;md5=165287851294f2fb8ac8cbc5e24b02b0 \
    file://WHENCE;md5=eee256607278e4eebd2eba4193d0bd9c \
    file://conf.d/hexagon-dsp-binaries-qualcomm-iq9075-evk.yaml;endline=2;md5=077232564320a8fce4ea446daad3d726 \
"

SRCREV = "7780697e3de9d7afbecc3f0a4dbad30fe449d73a"
