require hexagon-dsp-binaries.inc

LIC_FILES_CHKSUM = "\
    file://LICENSE.MIT;md5=3e312ffe200717dca92f8cec0dae6290 \
    file://LICENSE.qcom;md5=56e86b6c508490dadc343f39468b5f5e \
    file://LICENSE.qcom-2;md5=165287851294f2fb8ac8cbc5e24b02b0 \
    file://WHENCE;md5=307e2313e69e976a91f92d81ca4b3966  \
"

SRCREV = "862bb2be09dbd2e7f1c3f80cd0a384bb5aef1b34"
